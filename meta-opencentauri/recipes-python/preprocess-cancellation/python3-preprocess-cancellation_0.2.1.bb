SUMMARY = "GCode processor to add klipper cancel-object markers"
LICENSE = "GPL-3.0-only"
LIC_FILES_CHKSUM = "file://LICENSE;md5=1ebbd3e34237af26da5dc08a4e440464"

PYPI_PACKAGE = "preprocess_cancellation"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "e2f1224e1ba1603bdfdbf6937caaf91082dc849e5122e80a5328aa999433ce79"
