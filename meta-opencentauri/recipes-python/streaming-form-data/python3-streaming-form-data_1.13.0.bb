SUMMARY = "A Python parser for parsing multipart/form-data input chunks"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=297bf03ed7725a462a4450e7e00fb361"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "34087788c88912caa5b658020d1df66320369a8d98ec3a427dc36fd2618d864f"
