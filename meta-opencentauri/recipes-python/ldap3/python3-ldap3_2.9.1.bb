SUMMARY = "A strictly RFC 4510 conforming LDAP V3 pure Python client library"
LICENSE = "LGPL-3.0-only"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=f7cca0828c9444b3df38052275f0cec0"

inherit pypi python_setuptools_build_meta
SRC_URI[sha256sum] = "f3e7fc4718e3f09dda568b57100095e0ce58633bcabbed8667ce3f8fbaa4229f"
