FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://lines1.png"
SPLASH_IMAGES = "file://lines1.png;outsuffix=default"
